# Keil uVision project 悬挂运动控制系统.uvproj, settings and files
target 悬挂运动控制系统 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 悬挂运动控制系统 +hex
  c flags: Optimize=8 SizeSpeed=1
  group ABS_TASK
    ../SOFTWARE/ABS_TASK/: absTask.c
  group TASK
    ../SOFTWARE/TASK/: task.c setup.c mode.c direction.c
  group OS
    ../SOFTWARE/RTOS/: Conf_tny.A51
  group ALGORITHM
    ../SOFTWARE/ALGORITHM/FILTER/: FILTER.C
  group COMMON_SOFTWARE
    ../SOFTWARE/COMMON_SOFTWARE/DATA_SCOPE/: DataScope_DP.c
    ../SOFTWARE/COMMON_SOFTWARE/STORAGE/: storage.c
  group DEVICES
    ../HARDWARE/DEVICES/BUTTON/: BUTTON.C
    ../HARDWARE/DEVICES/LED/: LED.c
    ../HARDWARE/DEVICES/MOTOR/STEP_MOTOR/: STEP_MOTOR.C
    ../HARDWARE/DEVICES/DISPLAY/LCD5110/: LCD5510_V2.C
    ../HARDWARE/DEVICES/SENSOR/ANGLE/: ANGLE.C
  group COMMON_HARDWARE
    ../HARDWARE/COMMON_HARDWARE/: fixedPulser.c
  group BSP
    ../HARDWARE/BSP/: delay.c GPIO.c stc15_pwm.c timer.c USART1.C ADC.c
